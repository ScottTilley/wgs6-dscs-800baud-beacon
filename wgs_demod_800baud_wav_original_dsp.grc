options:
  parameters:
    author: Daniel Estevez
    description: Original working WGS 800-baud demodulator with only the live UDP input replaced by the actual 48 kHz stereo GQRX WAV source. All DSP settings are preserved from the working live flowgraph.
    generate_options: qt_gui
    id: dscs_demod_800baud
    output_language: python
    title: WGS-6 800 baud WAV demodulator
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: Raw soft BPSK symbols before differential decoding.
    file: /home/scott/Dropbox/satobs/wgs/write_up/wgs6/symbols_800baud_wgs6.f32
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: 'Required for file playback: limit WAV source to the original 48 ksample/s real-time rate.'
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: 'Actual GQRX recording: 48 kHz, stereo, signed 16-bit PCM. Both channels are bit-identical; use channel 0.'
    file: /home/scott/Dropbox/satobs/wgs/write_up/wgs6/gqrx_20260809_013115_7678620720_wgs6.wav
    repeat: 'False'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.05'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: 48 kS/s / 8 decimation = 6 kS/s; 7.5 samples/symbol at 800 baud.
    damping: '1.0'
    loop_bw: '0.005'
    max_dev: '0.1'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: '7.5'
    ted_gain: '1.47'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '1600'
    comment: Translate selected ~800 baud subcarrier to baseband; tune GQRX so it appears near +1600 Hz.
    decim: '8'
    samp_rate: samp_rate
    taps: firdes.low_pass(1, samp_rate, 1000, 300)
    type: fcc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Raw 800 baud BPSK constellation"'
    size: '1024'
    type: complex
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-3'
    reference: '1.0'
  states: {}

connections:
- [blocks_complex_to_real_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', satellites_rms_agc_0, '0']
- [satellites_rms_agc_0, '0', digital_symbol_sync_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
